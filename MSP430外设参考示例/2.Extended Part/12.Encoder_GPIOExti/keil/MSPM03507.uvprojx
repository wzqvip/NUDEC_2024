# Keil uVision project MSPM03507.uvprojx, settings and files
target MSPM03507 (6180000::V6.18::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G_DFP.1.2.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ncontroller +hex
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..\Start\source\third_party\CMSIS\Core\Include;..\Start\source;..\;..\USER
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\mspm0g3507.sct
  group User
    ../USER/: main.c A_include.h
    ../: ncontroller.syscfg ti_msp_dl_config.c ti_msp_dl_config.h
    ./: startup_mspm0g350x_uvision.s
  group hardware
    ../hardware/LED/: LED.c
    ../hardware/KEY/: KEY.c
    ../hardware/OLED/: OLED_Data.c oled.c
    ../hardware/Exti/: Exti.c
    ../hardware/ADC/: ADC.c
    ../hardware/Motor/: Motor.c
    ../hardware/Sever/: Sever.c
    ../hardware/DAC/: DAC.c
    ../hardware/HMC5883/: HMC5883.c
    ../hardware/Encoder/: Encoder.c
  group software
    ../software/Timer/: Timer.c
    ../software/UART/: UART.c
    ../software/MYIIC/: MYIIC.c
    ../software/delay/: delay.c
    ../software/MYSPI/: MYSPI.c
  group Start
    ../Start/source/ti/driverlib/: dl_adc12.c dl_adc12.h dl_aes.c dl_aes.h dl_aesadv.c dl_aesadv.h dl_common.c dl_common.h dl_comp.h dl_crc.c dl_crc.h dl_crcp.c dl_crcp.h dl_dac12.c dl_dac12.h dl_dma.c dl_dma.h dl_flashctl.c dl_flashctl.h dl_gpamp.h dl_gpio.h dl_i2c.c dl_i2c.h dl_iwdt.h dl_keystorectl.c dl_keystorectl.h dl_lcd.c dl_lcd.h dl_lfss.c dl_lfss.h dl_mathacl.c dl_mathacl.h dl_mcan.c dl_mcan.h dl_opa.c dl_opa.h dl_rtc.h dl_rtc_a.h dl_rtc_common.c dl_rtc_common.h dl_scratchpad.h dl_spi.c dl_spi.h dl_tamperio.h dl_timer.c dl_timer.h dl_timera.h dl_timerg.h dl_trng.c dl_trng.h dl_uart.c dl_uart.h dl_uart_extend.h dl_uart_main.h dl_vref.c dl_vref.h dl_wwdt.h driverlib.h
  group MPU
    ../hardware/mpu/: inv_mpu.c inv_mpu_dmp_motion_driver.c mpu6050.c
